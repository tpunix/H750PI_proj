# Keil uVision project h7pi.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: h7pi
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x10000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT8: RAM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Main
    ./Main/: main.c printk.c uart4.c mc_w.l sdio_h7.c tusb_host_user.c
  group Startup
    ./Startup/: startup_stm32h750xx.s system_init.c
  group TeenyUSB
    ./TeenyUSB/: stm32_otg_init.c teeny_usb_stm32_otg_host.c tusb_rtx5_os.c tusbh.c tusbh_hid.c tusbh_hid_parse.c tusbh_msc.c
  group Include
    ./inc/: board_config.h hidef.h stm32_fs_platform.h stm32_otg_platform.h teeny_usb.h teeny_usb_platform.h tntfs.h tusb_def.h tusb_msc.h tusb_scsi.h tusbd.h tusbd_hid.h tusbh.h tusbh_hid.h tusbh_msc.h tusbh_os.h
  group TntFS
    ./tntfs/: fs_ntfs.c fs_util.c fs_fat.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2
